do_install:append() {
    
    chown -R 0:0 ${D}
}