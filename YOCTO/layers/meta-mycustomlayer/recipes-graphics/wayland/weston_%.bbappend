PACKAGECONFIG:append = " rdp"